# IAR project iarproject.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: Common; AHardware\Registers\STM32F411\FieldValues; AHardware\Registers\STM32F411; AHardware\Registers; AHardware\Registers\CortexM4; AHardware\Registers\CortexM4\FieldValues; Application\Led\Contracts; Application\Led; Application\Mode\Contracts; Application\Button; Application\Button\Contrats; Application\LcdController; Application\LcdController\Contracts; Application\Mode
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: Rtos; Rtos\FreeRtos; Rtos\FreeRtos\include; Rtos\FreeRtos\portable\IAR; Rtos\FreeRtos\portable\IAR\ARM_CM4F; Rtos\wrapper\FreeRtos; Rtos\wrapper
  OBJCOPY.OOCOutputFile: iarproject.srec
  ILINK.IlinkOutputFile: iarproject.out
  ILINK.IlinkIcfFile: stm32f411xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: main.cpp startupF411RE.cpp TestDynamic.h
  group AHardware/Registers
    AHardware/Registers/: accessmode.hpp fieldvalue.hpp fieldvaluebase.hpp register.hpp registerbase.hpp registerfield.hpp registertype.hpp
  group AHardware/Registers/CortexM4
    AHardware/Registers/CortexM4/: fpucpacrregisters.hpp fpuregisters.hpp mpuregisters.hpp nvicregisters.hpp nvicstirregisters.hpp scbactrlregisters.hpp scbregisters.hpp stkregisters.hpp
  group AHardware/Registers/STM32F411
    AHardware/Registers/STM32F411/: adc1registers.hpp adccommonregisters.hpp crcregisters.hpp dbgregisters.hpp dma1registers.hpp dma2registers.hpp extiregisters.hpp flashregisters.hpp gpioaregisters.hpp gpiobregisters.hpp gpiocregisters.hpp gpiodregisters.hpp gpioeregisters.hpp gpiohregisters.hpp i2c1registers.hpp i2c2registers.hpp i2c3registers.hpp i2s2extregisters.hpp i2s3extregisters.hpp iwdgregisters.hpp otgfsdeviceregisters.hpp otgfsglobalregisters.hpp otgfshostregisters.hpp otgfspwrclkregisters.hpp portslist.hpp pwrregisters.hpp rccregisters.hpp rtcregisters.hpp sdioregisters.hpp spi1registers.hpp spi2registers.hpp spi3registers.hpp spi4registers.hpp spi5registers.hpp syscfgregisters.hpp tim10registers.hpp tim11registers.hpp tim1registers.hpp tim2registers.hpp tim3registers.hpp tim4registers.hpp tim5registers.hpp tim8registers.hpp tim9registers.hpp usart1registers.hpp usart2registers.hpp usart6registers.hpp wwdgregisters.hpp
  group Application/Button
    Application/Button/: UserButton.cpp UserButton.h
  group Application/Button/Contracts
    Application/Button/Contrats/: IButton.h
  group Application/LcdController
    Application/LcdController/: ModeController.cpp ModeController.h
  group Application/LcdController/Contracts
    Application/LcdController/Contracts/: IController.h
  group Application/Led
    Application/Led/: Led.cpp Led.h
  group Application/Led/Contracts
    Application/Led/Contracts/: ILedOnOff.h ILedToggable.h
  group Application/Mode
    Application/Mode/: ChessMode.cpp ChessMode.h CommonMode.cpp CommonMode.h FadeGlowMode.cpp FadeGlowMode.h ModeConfig.h RunningLightMode.cpp RunningLightMode.h
  group Application/Mode/Contracts
    Application/Mode/Contracts/: IMode.h
  group Common
    Common/: utils.hpp
